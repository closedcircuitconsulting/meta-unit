FILESEXTRAPATHS:prepend := "${UNIT_PROFILING_LAYERDIR}/recipes-kernel/linux/files:"

require recipes-kernel/linux/unit-profiling.inc
