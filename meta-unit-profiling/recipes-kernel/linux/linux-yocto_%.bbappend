FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

require unit-profiling.inc
