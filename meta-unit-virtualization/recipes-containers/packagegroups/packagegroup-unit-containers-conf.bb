SUMMARY = "Unit container configuration"

inherit packagegroup

RDEPENDS:${PN}:append = " storage-conf"
