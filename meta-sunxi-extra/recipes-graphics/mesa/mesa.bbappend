PACKAGECONFIG:append:pine64-pinephone-braveheart = " lima"
