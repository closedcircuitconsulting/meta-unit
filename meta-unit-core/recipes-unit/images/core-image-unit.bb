SUMMARY = "Unit image"

LICENSE = "MIT"

inherit fix-unitexe-home-dir-ownership

require unit-image-base.inc
