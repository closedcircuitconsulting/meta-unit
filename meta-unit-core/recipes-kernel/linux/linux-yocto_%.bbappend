KERNEL_FEATURES:append = " features/pwm/pwm.scc"
