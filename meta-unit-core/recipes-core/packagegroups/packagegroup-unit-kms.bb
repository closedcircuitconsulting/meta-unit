SUMMARY = "Unit KMS packages"

inherit packagegroup

RDEPENDS:${PN}:append = " kmscube"
