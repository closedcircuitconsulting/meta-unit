inherit enable-linger
inherit set-xdg-env

RDEPENDS:${PN}:append = " banner-quadlet"
