FILESEXTRAPATHS:prepend := "${UNIT_CORE_LAYERDIR}/recipes-kernel/linux/files:"

require recipes-kernel/linux/psi.inc
