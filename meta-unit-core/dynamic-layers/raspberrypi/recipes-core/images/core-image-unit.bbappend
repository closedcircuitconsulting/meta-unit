IMAGE_FEATURES:append:raspberrypi3-64 = " boot-splash"
