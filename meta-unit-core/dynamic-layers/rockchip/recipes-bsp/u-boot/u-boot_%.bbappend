FILESEXTRAPATHS:prepend := "${THISDIR}/files:"


SRC_URI:append = " file://increase_sys_bootm_len.cfg"
