IMAGE_FEATURES:append:radxa-zero-3e = " observability"
