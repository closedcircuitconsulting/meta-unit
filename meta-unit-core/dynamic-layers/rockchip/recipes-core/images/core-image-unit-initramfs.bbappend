PACKAGE_INSTALL:append:radxa-zero-3e = " \
    initramfs-graphics-modules \
    kernel-module-rockchipdrm \
    kernel-module-dw-mipi-dsi \
    kernel-module-dw-hdmi \
    kernel-module-dw-hdmi-qp \
    kernel-module-dw-hdmi-cec \
    kernel-module-analogix-dp \
    kernel-module-drm-display-helper \
    kernel-module-drm-dma-helper \
    kernel-module-drm-dp-aux-bus \
    kernel-module-cec \
    kernel-module-panfrost \
    kernel-module-gpu-sched \
"
