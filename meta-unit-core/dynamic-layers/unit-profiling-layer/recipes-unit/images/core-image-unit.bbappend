IMAGE_INSTALL:append = " packagegroup-unit-profiling"
IMAGE_INSTALL:append = " packagegroup-unit-systemd-profiling"
