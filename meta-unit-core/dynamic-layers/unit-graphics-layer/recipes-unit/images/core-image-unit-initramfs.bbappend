INITRAMFS_SCRIPTS:append = " initramfs-module-plymouth"
INITRAMFS_SCRIPTS:append:beaglebone-yocto = " initramfs-module-plymouthsettle"
