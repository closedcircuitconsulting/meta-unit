IMAGE_INSTALL:append = " packagegroup-unit-rpi"
