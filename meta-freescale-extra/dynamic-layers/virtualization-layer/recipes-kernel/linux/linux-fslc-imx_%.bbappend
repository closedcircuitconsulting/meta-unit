KERNEL_FEATURES:append = " features/netfilter/netfilter.cfg"
