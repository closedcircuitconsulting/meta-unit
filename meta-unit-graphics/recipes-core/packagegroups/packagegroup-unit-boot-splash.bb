SUMMARY = "Unit boot splash"

inherit packagegroup

RDEPENDS:${PN}:append = " u-boot-splash"
