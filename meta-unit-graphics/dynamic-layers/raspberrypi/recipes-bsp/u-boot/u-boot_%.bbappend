FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://splash.cfg"
SRC_URI:append = " file://0001-tweak-rpi-environment.patch"
