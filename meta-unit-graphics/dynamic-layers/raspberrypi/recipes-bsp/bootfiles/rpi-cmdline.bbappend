CMDLINE:append = " vt.global_cursor_default=0"
CMDLINE:append = " splash"
