LINUX_VERSION = "6.18.35"

SRCREV_machine = "71f493dd5f8072d1298475ed8a16fd38e8378f4b"
SRCREV_meta = "4101033495af309ba83fc76eb3c0cbd0fb030f8c"
