FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-set-serial2-baudrate-to-115200.patch"
