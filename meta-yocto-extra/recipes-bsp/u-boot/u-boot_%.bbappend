FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " file://0001-use-custom-boneblack-dtb-in-findfdt.patch"
